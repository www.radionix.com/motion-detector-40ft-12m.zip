Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2023-12-22T09:49:33
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.1.30.34 - Alternate UI 22.1.30.34

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 ft

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Nível:Nível 1, Nível 1
LongName: Nível 1; Elevation: 0 ft

# IfcBuildingElementProxy: Bosch_Detection Field_CTN_ISC-BDL2-W12GE:Standard, Bosch_Detection Field_CTN_ISC-BDL2-W12GE:Standard:17685
In: Nível 1
Type - Material: R_Bosch (2), I_Bosch (2)
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2

# IfcBuildingElementProxy: Bosch_Detection Field_CTN_ISC-BDL2-W12GE_2:Standard, Bosch_Detection Field_CTN_ISC-BDL2-W12GE_2:Standard:17686
In: Nível 1
Type - Material: I_Bosch2 (2), R_Bosch2
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2

# IfcBuildingElementProxy: D_Detection Field FOV2:Standard, D_Detection Field FOV2:Standard:17684
In: Nível 1
Type - Material: Xtech_Bosch_ABS_White
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2

# IfcDistributionControlElement: Motion Detector, 40ft (12m), Intrusion-Products_Bosch_Motion_Detector, 40ft (12m):Motion Detector, 40ft (12m):17683
In: Nível 1
Type - PredefinedType: MOVEMENTSENSOR; Classification: Pr_75_80_42_16 Combined passive infrared and microwave movement detectors (Uniclass 2015); Material: Bosch_Withe (4)
Type - Pset_ElementShading - Color: White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Bosch Security Systems
Pset_QuantityTakeOff - Reference: Motion Detector, 40ft (12m)
